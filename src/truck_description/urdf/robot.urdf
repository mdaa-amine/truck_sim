Commit message: Update robot.urdf

File: src/truck_description/urdf/robot.urdf (robot description, URDF)
Before this commit: robot simple_example, 15 links, 14 joints
Links:
- removed link logo_link
Joints:
- removed joint logo_joint
